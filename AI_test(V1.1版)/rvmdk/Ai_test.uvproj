# Keil uVision project Ai_test.uvproj, settings and files
target AI_test_flashmode (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ai_test +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_FULL_ASSERT,USE_STDPERIPH_DRIVER,AI_SUBCORE,LXIV_POINT,__CC_ARM,WATCHDOG
  c include: ..\STM32F10x_StdPeriph_Driver\inc; ..\CMSIS;..\user;..\BSP;..\DSPLIB_MDK;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group cmsis
    ../CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.h startup_stm32f10x_hd.s
  group std_periph_driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_wwdg.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c
  group user
    ../user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c Realtimedb.c
  group bsp
    ../BSP/: bsp.c BaseBus_Protocol.c adc_calc.c dft.c I2CRoutines.c
  group fft
    E:/测控/AI_test（20110803）/DSPLIB_MDK/: cr4_fft_64_stm32.s
    E:/测控/代码/MEASURE/DSPLib/include/: table_fft.h stm32_dsp.h
